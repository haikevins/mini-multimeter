# Keil uVision project mini-multimeter.uvprojx, settings and files
target mini-multimeter (6140000::V6.14::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mini-multimeter +hex
  c flags: Optim=2 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\Application;..\Services;..\Drivers;..\Infrastructure;..\Platform
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Application/: main.c app_controller.c ui_controller.c ui_view.c ui_formatter.c
  group Services
    ../Services/: config_service.c measurement_service.c signal_generator_service.c
  group Drivers
    ../Drivers/: adc_driver.c button_driver.c capacitor_charge_driver.c lcd1602_driver.c pwm_capture_driver.c pwm_output_driver.c flash_storage_driver.c
  group Infrastructure
    ../Infrastructure/: debug_logger.c error_manager.c
  group Platform
    ../Platform/: platform_init.c system_time.c uart_port.c
software components: CMSIS:CORE 6.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
